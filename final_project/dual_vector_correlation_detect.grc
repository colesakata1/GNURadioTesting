options:
  parameters:
    author: Claude
    description: Transmit two different vectors at different frequencies, add AWGN, then cross-correlate to detect each vector.
    gen_linking: subprocess
    generate_options: qt_gui
    id: dual_vector_correlation_detect
    output_language: python
    title: Dual Vector Correlation Detector
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: f1
  id: variable
  parameters:
    comment: Carrier offset for vector 1
    value: '100000'
  states: {}
- name: f2
  id: variable
  parameters:
    comment: Carrier offset for vector 2
    value: '-150000'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    comment: AWGN amplitude
    value: '0.3'
  states: {}
- name: vec1
  id: variable
  parameters:
    comment: 13-bit Barker code
    value: '[1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1]'
  states: {}
- name: vec2
  id: variable
  parameters:
    comment: 11-bit Barker code (different, orthogonal-ish)
    value: '[1, 1, 1, -1, -1, -1, 1, -1, -1, 1, -1]'
  states: {}
- name: threshold
  id: variable
  parameters:
    comment: Detection threshold (tune based on vector length & noise)
    value: '8.0'
  states: {}
- name: vector_source_1
  id: blocks_vector_source_x
  parameters:
    comment: Repeats vector 1 indefinitely
    repeat: 'True'
    type: complex
    vector: vec1
  states: {}
- name: vector_source_2
  id: blocks_vector_source_x
  parameters:
    comment: Repeats vector 2 indefinitely
    repeat: 'True'
    type: complex
    vector: vec2
  states: {}
- name: sig_source_f1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Carrier 1
    freq: f1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: sig_source_f2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Carrier 2
    freq: f2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: mixer_1
  id: blocks_multiply_xx
  parameters:
    comment: Shift vector 1 to f1
    type: complex
  states: {}
- name: mixer_2
  id: blocks_multiply_xx
  parameters:
    comment: Shift vector 2 to f2
    type: complex
  states: {}
- name: adder_signals
  id: blocks_add_xx
  parameters:
    comment: Sum the two transmitted signals
    type: complex
  states: {}
- name: noise_source
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    comment: AWGN channel
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: adder_noise
  id: blocks_add_xx
  parameters:
    comment: Add noise to combined signal
    type: complex
  states: {}
- name: sig_source_neg_f1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Downshift by f1
    freq: '-f1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: sig_source_neg_f2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Downshift by f2
    freq: '-f2'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: downmix_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: downmix_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: matched_filter_1
  id: filter_fir_filter_xxx
  parameters:
    comment: Cross-correlate against vec1 (taps = conj(reverse(vec1)))
    decim: '1'
    samp_delay: '0'
    taps: list(numpy.conj(numpy.array(vec1)[::-1]))
    type: ccc
  states: {}
- name: matched_filter_2
  id: filter_fir_filter_xxx
  parameters:
    comment: Cross-correlate against vec2 (taps = conj(reverse(vec2)))
    decim: '1'
    samp_delay: '0'
    taps: list(numpy.conj(numpy.array(vec2)[::-1]))
    type: ccc
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: mag_1
  id: blocks_complex_to_mag
  parameters:
    comment: abs(correlation)
  states: {}
- name: mag_2
  id: blocks_complex_to_mag
  parameters:
    comment: abs(correlation)
  states: {}
- name: threshold_det_1
  id: blocks_threshold_ff
  parameters:
    comment: Vector 1 detected when output = 1
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: threshold_det_2
  id: blocks_threshold_ff
  parameters:
    comment: Vector 2 detected when output = 1
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: qtgui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: View transmitted spectrum
    fc: '0'
    fftsize: '1024'
    label1: Tx + Noise
    name: '"Received Spectrum (with noise)"'
    type: complex
  states: {}
- name: qtgui_time_sink_corr
  id: qtgui_time_sink_x
  parameters:
    comment: Magnitude of correlation outputs
    label1: '|corr vec1|'
    label2: '|corr vec2|'
    name: '"Cross-Correlation Outputs"'
    nconnections: '2'
    size: '2048'
    srate: samp_rate
    type: float
    ylabel: Magnitude
    ymax: '20'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_detect
  id: qtgui_time_sink_x
  parameters:
    comment: Binary detection flags
    label1: vec1 detected
    label2: vec2 detected
    name: '"Detection Flags"'
    nconnections: '2'
    size: '2048'
    srate: samp_rate
    type: float
    ylabel: Detected
    ymax: '1.5'
    ymin: '-0.2'
  states: {}

connections:
- [vector_source_1, '0', mixer_1, '0']
- [sig_source_f1, '0', mixer_1, '1']
- [vector_source_2, '0', mixer_2, '0']
- [sig_source_f2, '0', mixer_2, '1']
- [mixer_1, '0', adder_signals, '0']
- [mixer_2, '0', adder_signals, '1']
- [adder_signals, '0', adder_noise, '0']
- [noise_source, '0', adder_noise, '1']
- [adder_noise, '0', qtgui_freq_sink, '0']
- [adder_noise, '0', downmix_1, '0']
- [sig_source_neg_f1, '0', downmix_1, '1']
- [downmix_1, '0', matched_filter_1, '0']
- [matched_filter_1, '0', mag_1, '0']
- [mag_1, '0', threshold_det_1, '0']
- [mag_1, '0', qtgui_time_sink_corr, '0']
- [threshold_det_1, '0', qtgui_time_sink_detect, '0']
- [adder_noise, '0', downmix_2, '0']
- [sig_source_neg_f2, '0', downmix_2, '1']
- [downmix_2, '0', matched_filter_2, '0']
- [matched_filter_2, '0', mag_2, '0']
- [mag_2, '0', threshold_det_2, '0']
- [mag_2, '0', qtgui_time_sink_corr, '1']
- [threshold_det_2, '0', qtgui_time_sink_detect, '1']

metadata:
  file_format: 1
