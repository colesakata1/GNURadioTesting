options:
  parameters:
    description: |
      Two sinusoidal sources at different frequencies are summed with AWGN noise. A cross-correlation (matched-filter) detector determines whether each source is actively transmitting. Toggle source amplitudes with the sliders to observe the correlation outputs change in real time.
    id: cross_correlation_detector
    output_language: python
    title: Two-Source Cross-Correlation Detector
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate (Hz)
    value: '32000'
  states: {}
- name: freq1
  id: variable
  parameters:
    comment: Source 1 carrier frequency (Hz)
    value: '1000'
  states: {}
- name: freq2
  id: variable
  parameters:
    comment: Source 2 carrier frequency (Hz)
    value: '5000'
  states: {}
- name: src1_amp
  id: variable_qtgui_range
  parameters:
    comment: Source 1 amplitude (0 = off)
    gui_hint: 0,0,1,1
    label: Source 1 Amplitude (1 kHz)
    start: '0'
    step: '0.05'
    stop: '1'
    value: '1'
  states: {}
- name: src2_amp
  id: variable_qtgui_range
  parameters:
    comment: Source 2 amplitude (0 = off)
    gui_hint: 0,1,1,1
    label: Source 2 Amplitude (5 kHz)
    start: '0'
    step: '0.05'
    stop: '1'
    value: '1'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    comment: AWGN noise standard deviation
    gui_hint: 0,2,1,1
    label: Noise Amplitude (AWGN)
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.3'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: src1_amp
    comment: Source 1 — 1 kHz sinusoid
    freq: freq1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: src2_amp
    comment: Source 2 — 5 kHz sinusoid
    freq: freq2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    comment: Additive White Gaussian Noise
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: 'Channel: src1 + src2 + AWGN'
    num_inputs: '3'
    type: float
  states: {}
- name: analog_sig_source_ref1_cos
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: 'Local reference: cos(2π·1kHz·t)'
    freq: freq1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_ref1_sin
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: 'Local reference: sin(2π·1kHz·t)'
    freq: freq1
    offset: '0'
    phase: '1.5707963267948966'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_ref2_cos
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: 'Local reference: cos(2π·5kHz·t)'
    freq: freq2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_ref2_sin
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: 'Local reference: sin(2π·5kHz·t)'
    freq: freq2
    offset: '0'
    phase: '1.5707963267948966'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_corr1_i
  id: blocks_multiply_xx
  parameters:
    comment: 'Corr1-I: rx × cos_ref1'
    type: float
  states: {}
- name: blocks_multiply_corr1_q
  id: blocks_multiply_xx
  parameters:
    comment: 'Corr1-Q: rx × sin_ref1'
    type: float
  states: {}
- name: blocks_multiply_corr2_i
  id: blocks_multiply_xx
  parameters:
    comment: 'Corr2-I: rx × cos_ref2'
    type: float
  states: {}
- name: blocks_multiply_corr2_q
  id: blocks_multiply_xx
  parameters:
    comment: 'Corr2-Q: rx × sin_ref2'
    type: float
  states: {}
- name: low_pass_filter_c1i
  id: low_pass_filter
  parameters:
    comment: Integrate I-branch, Src1
    cutoff_freq: '100'
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_c1q
  id: low_pass_filter
  parameters:
    comment: Integrate Q-branch, Src1
    cutoff_freq: '100'
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_c2i
  id: low_pass_filter
  parameters:
    comment: Integrate I-branch, Src2
    cutoff_freq: '100'
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_c2q
  id: low_pass_filter
  parameters:
    comment: Integrate Q-branch, Src2
    cutoff_freq: '100'
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters:
    comment: Pack I+Q for Src1 correlator
  states: {}
- name: blocks_float_to_complex_2
  id: blocks_float_to_complex
  parameters:
    comment: Pack I+Q for Src2 correlator
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters:
    comment: 'Detection metric — Src1: high = transmitting'
  states: {}
- name: blocks_complex_to_mag_2
  id: blocks_complex_to_mag
  parameters:
    comment: 'Detection metric — Src2: high = transmitting'
  states: {}
- name: qtgui_time_sink_received
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,3
    label1: Received (Src1+Src2+Noise)
    name: '"Received Signal"'
    size: '2048'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_freq_sink_received
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,1,3
    label1: Received Signal
    name: '"Frequency Spectrum of Received Signal"'
    type: float
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_corr
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,1,3
    label1: Corr Magnitude — Source 1 (1 kHz)
    label2: Corr Magnitude — Source 2 (5 kHz)
    name: '"Cross-Correlation Detection Metric  (high = source transmitting)"'
    nconnections: '2'
    size: '2048'
    srate: samp_rate
    type: float
    width1: '2'
    width2: '2'
    ylabel: Correlation Magnitude
    ymax: '1.2'
    ymin: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', qtgui_time_sink_received, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_received, '0']
- [blocks_add_xx_0, '0', blocks_multiply_corr1_i, '0']
- [analog_sig_source_ref1_cos, '0', blocks_multiply_corr1_i, '1']
- [blocks_multiply_corr1_i, '0', low_pass_filter_c1i, '0']
- [low_pass_filter_c1i, '0', blocks_float_to_complex_1, '0']
- [blocks_add_xx_0, '0', blocks_multiply_corr1_q, '0']
- [analog_sig_source_ref1_sin, '0', blocks_multiply_corr1_q, '1']
- [blocks_multiply_corr1_q, '0', low_pass_filter_c1q, '0']
- [low_pass_filter_c1q, '0', blocks_float_to_complex_1, '1']
- [blocks_float_to_complex_1, '0', blocks_complex_to_mag_1, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_corr, '0']
- [blocks_add_xx_0, '0', blocks_multiply_corr2_i, '0']
- [analog_sig_source_ref2_cos, '0', blocks_multiply_corr2_i, '1']
- [blocks_multiply_corr2_i, '0', low_pass_filter_c2i, '0']
- [low_pass_filter_c2i, '0', blocks_float_to_complex_2, '0']
- [blocks_add_xx_0, '0', blocks_multiply_corr2_q, '0']
- [analog_sig_source_ref2_sin, '0', blocks_multiply_corr2_q, '1']
- [blocks_multiply_corr2_q, '0', low_pass_filter_c2q, '0']
- [low_pass_filter_c2q, '0', blocks_float_to_complex_2, '1']
- [blocks_float_to_complex_2, '0', blocks_complex_to_mag_2, '0']
- [blocks_complex_to_mag_2, '0', qtgui_time_sink_corr, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
