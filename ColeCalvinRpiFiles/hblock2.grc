options:
  parameters:
    category: '[ST_2026]'
    generate_options: hb
    id: hblock2
    output_language: python
    title: Power Block 2.0
  states: {}

blocks:
- name: ma_len
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: ma_len
    max_iter: '4000'
    scale: 1/(ma_len)
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: ''
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
