options:
  parameters:
    author: colesakata
    generate_options: qt_gui
    id: XMLRPC
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Sig_Type
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,4,1,1
    label: Waveform
    label0: Cosine
    label1: Square
    num_opts: '2'
    option0: '102'
    option1: '103'
    type: int
    value: '102'
  states: {}
- name: bandpass_highend_cutoff
  id: variable_qtgui_range
  parameters:
    label: Filter High-End Freq.
    start: '0'
    step: '10000'
    stop: '100000'
    value: '0'
    widget: eng_slider
  states: {}
- name: cmplx_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label: Source Signal
    label0: Real Sine
    label1: Complex Sine
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: filter_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,1,1
    label: Filter Selection
    label0: Enable
    label1: Bypass
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: noise_select
  id: variable_qtgui_chooser
  parameters:
    label0: Disabled
    label1: Enabled
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sig_amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: sig_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Signal Frequency
    start: 5e4
    step: 5e4
    stop: 5e5
    value: 1e5
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: sig_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: Sig_Type
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: sig_amp
    freq: sig_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: Sig_Type
  states: {}
- name: avg_power_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Average Power 1
    type: float
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: sig_freq + 25000 +bandpass_highend_cutoff
    low_cutoff_freq: sig_freq - 25000
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '2500'
    max_iter: '500'
    scale: 1/2500
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: cmplx_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: filter_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: noise_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle2_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: hblock2_0
  id: hblock2
  parameters: {}
  states: {state: disabled}
- name: powerHierBlock_0
  id: powerHierBlock
  parameters:
    ma_len: '1000'
    samp_rate: '1000000'
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '915000000'
    fftsize: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Real_Sine
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Complex_Sine
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: RxSignal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Real_Sine
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Complex_Sine
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: RxSignal
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '''tcp://127.0.0.1:55555'''
    hwm: '1'
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', virtual_sink_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_float_to_complex_0, '0']
- [band_pass_filter_0, '0', blocks_selector_0_0, '0']
- [blocks_add_xx_0, '0', blocks_selector_1, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_moving_average_xx_0, '0', avg_power_1, '0']
- [blocks_moving_average_xx_0, '0', zeromq_pub_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_2, '0']
- [blocks_selector_0, '0', blocks_add_xx_0, '0']
- [blocks_selector_0, '0', blocks_selector_1, '0']
- [blocks_selector_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_selector_0_0, '0', hblock2_0, '0']
- [blocks_selector_0_0, '0', powerHierBlock_0, '0']
- [blocks_selector_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_selector_1, '0', blocks_throttle2_2, '0']
- [blocks_throttle2_2, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle2_2, '0', virtual_sink_2, '0']
- [hblock2_0, '0', avg_power_1, '0']
- [hblock2_0, '0', zeromq_pub_sink_0, '0']
- [powerHierBlock_0, '0', avg_power_1, '0']
- [powerHierBlock_0, '0', zeromq_pub_sink_0, '0']
- [virtual_source_0, '0', blocks_selector_0, '0']
- [virtual_source_0_0, '0', blocks_selector_0, '1']
- [virtual_source_1, '0', band_pass_filter_0, '0']
- [virtual_source_1, '0', blocks_selector_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
