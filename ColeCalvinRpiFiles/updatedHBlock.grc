options:
  parameters:
    category: '[ST-2026]'
    generate_options: hb
    id: hierblock_power
    output_language: python
    title: Hier Power Calc
  states: {}

blocks:
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: ma_len
    max_iter: '500'
    scale: 1/ma_len
    type: float
  states: {}
- name: ma_len
  id: parameter
  parameters:
    label: length
    short_id: l
    type: intx
    value: '2500'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
