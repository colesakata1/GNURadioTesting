options:
  parameters:
    author: MR
    generate_options: qt_gui
    id: Rx_GUI
    output_language: python
    title: Receiver with GUI
  states: {}

blocks:
- name: addr_string
  id: variable
  parameters:
    value: '"serial=" + usrp_addr'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Carrier Frequency
    short_id: c
    type: eng_float
    value: 915e6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: Receiver Gain
    short_id: g
    type: eng_float
    value: '30'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: fc
    dc_offs_enb0: '""'
    dev_addr: addr_string
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: usrp_addr
  id: parameter
  parameters:
    label: USRP Address
    short_id: a
    type: str
    value: '3275253'
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
